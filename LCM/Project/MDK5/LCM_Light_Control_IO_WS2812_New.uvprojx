# Keil uVision project LCM_Light_Control_IO_WS2812_New.uvprojx, settings and files
target ADV (6220000::V6.22::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCM_ADV +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F030M, HK32F030MF4P6, ADV
  c include: ..\..\Code\App;..\..\Code\Drive;..\..\Code\User;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\HK32F030M_Lib\inc;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\CM0\Core;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\HK32F030M\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Startup
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/ARM/: KEIL_Startup_hk32f030m.s
  group User
    ../../Code/User/: main.c hk32f030m_it.c
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group App
    ../../Code/App/: ws2812.c crc.c vesc_uasrt.c test.c task.c flag_bit.c
  group Drive
    ../../Code/Drive/: led.c time.c spi.c power.c led_pwm.c key.c buzzer.c usart.c adc.c io_ws2812.c eeprom.c
  group Library
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_gpio.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_flash.c
  group Readme
    ../../Readme/: Readme.txt
target GTV (6220000::V6.22::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: as above
  output: LCM_GTV +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F030M, HK32F030MF4P6, GTV
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target PintV (6220000::V6.22::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: as above
  output: LCM_PintV +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F030M, HK32F030MF4P6, PINTV
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
target XRV (6220000::V6.22::ARMCLANG)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030Mxx_DFP.1.0.12
  cpu: as above
  output: LCM_XRV +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F030M, HK32F030MF4P6, XRV
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
